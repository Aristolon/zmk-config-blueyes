## config/boards/shields/blueyes/Kconfig.defconfig
```kconfig
if SHIELD_blueyes
            
config ZMK_KEYBOARD_NAME
    default "blueyes"

endif
```
